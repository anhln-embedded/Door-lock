# Keil uVision project door_lock.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: door_lock
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3
  memory RVCT4: ROM 0x8000000 size 0x11000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Delay
    ../USER/: delay.c delay.h
  group LCD
    ../USER/: lcd_i2c.h lcd_i2c.c
  group RFID
    ../USER/: spi.h spi.c mfrc522.h mfrc522.c
  group Keypab
    ../USER/: keypab.h keypab.c
  group AS608
    ../USER/: usart2.c usart2.h timer.c timer.h as608.h as608.c
  group Flash
    ../USER/: stmflash.h stmflash.c password.h password.c
  group main
    ../USER/: usart1.h usart1.c main.c
  group Motor
    ../USER/: motor.h motor.c
software components: RTOS:Config 10.5.1, RTOS:Core 10.5.1, RTOS:Coroutines 10.5.1, RTOS:Event Groups 10.5.1, RTOS:Heap 10.5.1, RTOS:Message Buffer 10.5.1, RTOS:Stream Buffer 10.5.1, RTOS:Timers 10.5.1, CMSIS:CORE 5.5.0, CMSIS:RTOS2:FreeRTOS 10.5.1, Device:Startup 1.0.0, Device:StdPeriph Drivers:Flash 3.6.0, Device:StdPeriph Drivers:Framework 3.6.0, Device:StdPeriph Drivers:GPIO 3.6.0, Device:StdPeriph Drivers:I2C 3.6.0, Device:StdPeriph Drivers:RCC 3.6.0, Device:StdPeriph Drivers:SPI 3.6.0, Device:StdPeriph Drivers:TIM 3.6.0, Device:StdPeriph Drivers:USART 3.6.0
